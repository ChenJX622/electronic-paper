# Keil uVision project FSP.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FSP +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group Source Group 1
    ./: max9814.c max9814.h snr9816.c snr9816.h uart_comm.c uart_comm.h ADC_MY.c ADC_MY.h dsp_process.c dsp_process.h hscr501.c hscr501.h mpu6050.c mpu6050.h display.c display.h asr_pro.h asr_pro.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
software components: Flex Software:RA Configuration 1.0.0
